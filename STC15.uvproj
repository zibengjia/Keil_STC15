# Keil uVision project STC15.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c SoundPlay.c SoundPlay.h DS1302.c DS1302.h hc595.c hc595.h key.c key.h lcd1602.c lcd1602.h main.h
